# Keil uVision project Template.uvprojx, settings and files
target Flight Control System (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\CMSIS;..\User\HAL;..\User\BSP;..\User\FML;..\User\APP;..\User\Common
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group ST_LIB
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_spi.c stm32f4xx_i2c.c stm32f4xx_usart.c stm32f4xx_dma.c
    ../Libraries/CMSIS/: startup_stm32f40_41xxx.s
  group Common
    ../User/Common/: com_math.cpp com_global.cpp com_test.cpp com_buffer.cpp com_defines.h
  group APP
    ../User/APP/: main.cpp stm32f4xx_it.c system_stm32f4xx.c
  group FML
    ../User/FML/: fml_ano_protocol.cpp fml_gps.cpp
  group BSP
    ../User/BSP/: bsp_mpu6k.cpp bsp_ms5611.cpp bsp_hmc5883l.cpp bsp_lc306.cpp bsp_ubloxm8n.cpp
  group HAL
    ../User/HAL/: hal_systick.cpp hal_gpio_led.cpp hal_spi.cpp hal_i2c.cpp hal_uart.cpp hal_timer_pwm.cpp hal_timer_cap.cpp hal_dma.cpp
